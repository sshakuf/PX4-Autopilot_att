## src/drivers/ir_cam/Kconfig
```kconfig
menuconfig DRIVERS_IR_CAM
	bool "ir_cam"
	default n
	---help---
		Enable support for the LSDT IR spot-detection camera (serial beacon tracker)
```
